#include "graphics.h"
#include "app.h"
#include <string.h>
static uint16_t *fb;
static const uint8_t font[][5] = {
 {0x3e,0x51,0x49,0x45,0x3e},{0,0x42,0x7f,0x40,0},{0x42,0x61,0x51,0x49,0x46},
 {0x21,0x41,0x45,0x4b,0x31},{0x18,0x14,0x12,0x7f,0x10},{0x27,0x45,0x45,0x45,0x39},
 {0x3c,0x4a,0x49,0x49,0x30},{1,0x71,9,5,3},{0x36,0x49,0x49,0x49,0x36},
 {6,0x49,0x49,0x29,0x1e},
 {0x7e,0x11,0x11,0x11,0x7e},{0x7f,0x49,0x49,0x49,0x36},{0x3e,0x41,0x41,0x41,0x22},
 {0x7f,0x41,0x41,0x22,0x1c},{0x7f,0x49,0x49,0x49,0x41},{0x7f,9,9,9,1},
 {0x3e,0x41,0x49,0x49,0x7a},{0x7f,8,8,8,0x7f},{0,0x41,0x7f,0x41,0},
 {0x20,0x40,0x41,0x3f,1},{0x7f,8,0x14,0x22,0x41},{0x7f,0x40,0x40,0x40,0x40},
 {0x7f,2,0x0c,2,0x7f},{0x7f,4,8,0x10,0x7f},{0x3e,0x41,0x41,0x41,0x3e},
 {0x7f,9,9,9,6},{0x3e,0x41,0x51,0x21,0x5e},{0x7f,9,0x19,0x29,0x46},
 {0x46,0x49,0x49,0x49,0x31},{1,1,0x7f,1,1},{0x3f,0x40,0x40,0x40,0x3f},
 {0x1f,0x20,0x40,0x20,0x1f},{0x3f,0x40,0x38,0x40,0x3f},{0x63,0x14,8,0x14,0x63},
 {7,8,0x70,8,7},{0x61,0x51,0x49,0x45,0x43}
};

void mc_gfx_buffer(uint16_t *pixels) { fb=pixels; }
void mc_gfx_rect(int x,int y,int w,int h,uint16_t color) {
    int xx,yy;
    for(yy=y<0?0:y;yy<y+h && yy<MC_HEIGHT;++yy)
        for(xx=x<0?0:x;xx<x+w && xx<MC_WIDTH;++xx)fb[yy*MC_WIDTH+xx]=color;
}
void mc_gfx_text(int x,int y,const char *s,int scale,uint16_t color) {
    while(*s) {
        int col,row,index=-1;char ch=*s++;
        if(ch>='a' && ch<='z')ch=(char)(ch-'a'+'A');
        if(ch=='*')ch='X';
        if(ch>='0' && ch<='9')index=ch-'0';
        if(ch>='A' && ch<='Z')index=ch-'A'+10;
        if(index>=0) {
            for(col=0;col<5;++col)for(row=0;row<7;++row)
                if(font[index][col]&(1u<<row))mc_gfx_rect(x+col*scale,y+row*scale,scale,scale,color);
        }else if(ch=='-')mc_gfx_rect(x,y+3*scale,5*scale,scale,color);
        else if(ch=='+'){mc_gfx_rect(x,y+3*scale,5*scale,scale,color);mc_gfx_rect(x+2*scale,y+scale,scale,5*scale,color);}
        else if(ch=='='){mc_gfx_rect(x,y+2*scale,5*scale,scale,color);mc_gfx_rect(x,y+4*scale,5*scale,scale,color);}
        else if(ch=='.')mc_gfx_rect(x+2*scale,y+6*scale,scale,scale,color);
        else if(ch=='/'){for(col=0;col<5;++col)mc_gfx_rect(x+col*scale,y+(5-col)*scale,scale,scale,color);}
        x+=6*scale;
    }
}
void mc_gfx_center(int y,const char *s,int scale,uint16_t color){
    mc_gfx_text((MC_WIDTH-(int)strlen(s)*6*scale+scale)/2,y,s,scale,color);
}
